<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\FISH_STM32F4_407vg_Disco_Port.ewp</path>
    </project>
    <batchBuild />
</workspace>
